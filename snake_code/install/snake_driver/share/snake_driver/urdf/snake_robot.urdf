Commit message: Bug do movimento periodico corrigido

File: snake_code/install/snake_driver/share/snake_driver/urdf/snake_robot.urdf (robot description, URDF)
Before this commit: robot Snake5R, 7 links, 6 joints
Joints:
- joint rotationalMotor5: axis 0 0 1 -> 0 -1 0
